module test;
    foo baz;
endmodule
